SUMMARY = "Temporary OneKVM extension lifecycle acceptance probe"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8a5a0a588995e3e2c2bfa68f5413df57"
EXCLUDE_FROM_WORLD = "1"
FILESEXTRAPATHS:prepend := "${THISDIR}/../../../tests/fixtures/lifecycle-probe:${THISDIR}/../../..:"
# The screen bundle is generated by tests/build-lifecycle-probe.sh and is not
# part of the tracked source tree. Only machines with a local screen consume
# it; headless machines use the fixture's non-screen test payload.
SRC_URI = "file://Makefile file://manifest.json.in file://probe.sh file://tool.js file://LICENSE"
SRC_URI:append:onekvm-with-screen = " file://screen-app"
# screen-app is generated and ignored by Git; skip the probe in a clean
# checkout so the missing directory does not stop parsing.
python () {
    if 'onekvm-with-screen' not in d.getVar('OVERRIDES').split(':'):
        return
    app = os.path.join(d.getVar('FILE_DIRNAME'), '../../../tests/fixtures/lifecycle-probe/screen-app')
    if not os.path.isdir(app):
        raise bb.parse.SkipRecipe('screen-app is missing; run tests/build-lifecycle-probe.sh')
}
S = "${UNPACKDIR}"
inherit onekvm-extension
OPKGBUILDCMD = "opkg-build -Z gzip"
ONEKVM_EXTENSION_ID = "lifecycle-probe"
ONEKVM_EXTENSION_API_VERSION = "2"
ONEKVM_EXTENSION_MANIFEST_TEMPLATE = "${S}/manifest.json.in"
RDEPENDS:${PN} += "onekvm-extension-host (>= 0.1.0-r35) onekvm-ui (>= 0.1.0-r67) onekvm-core (>= 0.1.0-r113)"
LIFECYCLE_PROBE_FAIL_HEALTH ?= "0"
do_configure[noexec] = "1"
do_compile[noexec] = "1"
do_install() {
    oe_runmake install DESTDIR=${D} PREFIX=${ONEKVM_EXTENSION_ROOT} VERSION=${PV} ARCH=${TARGET_ARCH} FAIL_HEALTH=${LIFECYCLE_PROBE_FAIL_HEALTH}
}
